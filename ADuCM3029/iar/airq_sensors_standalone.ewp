# IAR project airq_sensors_standalone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG
  ICCARM.CCIncludePath2: ../../../../inc; ../../../../inc/config; $AD3029_BSP_DIR$/inc; $AD3029_BSP_DIR$/inc/config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: airq_sensors_standalone.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../inc; ../../../../inc/config
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: Readme_airq_sensors_standalone.html
  group drivers
    $AD3029_BSP_DIR$/src/drivers/adc/: adi_adc.c
    $AD3029_BSP_DIR$/src/services/dma/: adi_dma.c
    $AD3029_BSP_DIR$/src/services/gpio/: adi_gpio.c
    $AD3029_BSP_DIR$/src/services/pwr/: adi_pwr.c
    $AD3029_BSP_DIR$/src/services/rtc/: adi_rtc.c
    $AD3029_BSP_DIR$/src/services/tmr/: adi_tmr.c
    $AD3029_BSP_DIR$/src/drivers/uart/: adi_uart.c
    $AD3029_BSP_DIR$/src/services/wdt/: adi_wdt.c
  group source
    ../../: airq_sensors_standalone.c
  group system
    $AD3029_BSP_DIR$/src/: common.c startup.c system.c
